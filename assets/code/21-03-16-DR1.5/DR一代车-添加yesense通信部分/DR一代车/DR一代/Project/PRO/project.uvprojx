# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__CC_ARM
  c include: ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\GeneralFunction\inc;..\..\Libraries\CMSIS;..\..\uCOSII\PORT;..\..\uCOSII\CORE;..\..\uCOSII\CONFIG;..\..\uCOSII\api\inc;..\..\driver\inc;..\..\User\inc;..\..\app\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../../User/src/: stm32f4xx_it.c delay.c filter.c kalman.c main.c PositionCount.c QEPtime.c queue.c ADS1255.c analysis_data.c
  group driver
    ../../driver/src/: led.c can.c time2.c spi2.c usart1.c
  group function
    ../../GeneralFunction/src/: MyDataProcess.c MyMath.c
  group lib
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_fsmc.c stm32f4xx_spi.c
    ../../Libraries/Startup/: startup_stm32f4xx.s
    ../../Libraries/CMSIS/: system_stm32f4xx.c
  group os_config
    ../../uCOSII/CONFIG/: includes.h os_cfg.h
  group os_core
    ../../uCOSII/CORE/: os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_core.c
  group os_port
    ../../uCOSII/PORT/: os_cpu_c.c os_dbg.c os_cpu_a.asm os_cpu.h
software components: CMSIS:CORE 3.20.0
